SUMMARY = "The Python CoAP library"
HOMEPAGE = "https://github.com/chrysn/aiocoap"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://PKG-INFO;beginline=9;endline=9;md5=8227180126797a0148f94f483f3e1489"

SRC_URI[sha256sum] = "90f3bcaffd454f5421d3ad55ddbe3fe10a686d4b9f3c4445d427b130493a96a4"

inherit pypi setuptools3
